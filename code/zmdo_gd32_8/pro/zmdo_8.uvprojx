# Keil uVision project zmdo_8.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: zmdo_8
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\device\include;..\frame
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../user/: app.c
  group device
    ../device/: can.c outsignal.c wdog.c flash.c tm1650.c time.c
  group frame
    ../frame/: fsm.h
software components: CMSIS:CORE 5.0.0, Device:GD32F10x_StdPeripherals:ADC 2.0.0, Device:GD32F10x_StdPeripherals:BKP 2.0.0, Device:GD32F10x_StdPeripherals:CAN 2.0.0, Device:GD32F10x_StdPeripherals:CRC 2.0.0, Device:GD32F10x_StdPeripherals:DAC 2.0.0, Device:GD32F10x_StdPeripherals:DBG 2.0.0, Device:GD32F10x_StdPeripherals:DMA 2.0.0, Device:GD32F10x_StdPeripherals:ENET 2.0.0, Device:GD32F10x_StdPeripherals:EXMC 2.0.0, Device:GD32F10x_StdPeripherals:EXTI 2.0.0, Device:GD32F10x_StdPeripherals:FMC 2.0.0, Device:GD32F10x_StdPeripherals:FWDGT 2.0.0, Device:GD32F10x_StdPeripherals:GPIO 2.0.0, Device:GD32F10x_StdPeripherals:I2C 2.0.0, Device:GD32F10x_StdPeripherals:MISC 2.0.0, Device:GD32F10x_StdPeripherals:PMU 2.0.0, Device:GD32F10x_StdPeripherals:RCU 2.0.0, Device:GD32F10x_StdPeripherals:RTC 2.0.0, Device:GD32F10x_StdPeripherals:SDIO 2.0.0, Device:GD32F10x_StdPeripherals:SPI_I2S 2.0.0, Device:GD32F10x_StdPeripherals:TIMER 2.0.0, Device:GD32F10x_StdPeripherals:USART 2.0.0, Device:GD32F10x_StdPeripherals:WWDGT 2.0.0, Device:GD32F10x_libopt 2.0.0, Device:Startup 2.0.0
