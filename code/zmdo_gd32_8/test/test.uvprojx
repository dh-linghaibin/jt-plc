# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\freertos\include;..\freertos\portable\RVDS\ARM_CM3;..\test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
  group e
    ../freertos/portable/MemMang/: heap_2.c
    ../freertos/portable/RVDS/ARM_CM3/: port.c
    ../freertos/: list.c queue.c tasks.c
software components: CMSIS:CORE 5.0.0, Device:GD32F10x_StdPeripherals:MISC 2.0.0, Device:GD32F10x_StdPeripherals:PMU 2.0.0, Device:GD32F10x_StdPeripherals:RCU 2.0.0, Device:GD32F10x_libopt 2.0.0, Device:Startup 2.0.0
