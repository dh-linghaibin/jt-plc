# IAR project stm32_uip.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: CMSIS; StdPeriph_Driver\inc; User; uIP-1.0\uip; hello-world; FreeModbus\modbus\include; FreeModbus\modbus\tcp; FreeModbus\port; C:\Users\a6735\LHB_DATA\03-project\53-jt_plc\code\Muip_freemodbus_tcp\FreeModbus\modbus
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32_uip.hex
  ILINK.IlinkOutputFile: STM32-uIP.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    CMSIS/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FreeModbus
    FreeModbus/modbus/: mb_l.c
  group FreeModbus/modbus
    FreeModbus/modbus/: mb_m.c
    FreeModbus/port/: user_mb_app_m.c
  group FreeModbus/modbus/functions
    FreeModbus/modbus/functions/: mbfunccoils_m.c mbfuncdisc_m.c mbfuncholding_m.c mbfuncinput_m.c
  group FreeModbus/modbus/include
    FreeModbus/modbus/include/: mb.h mb_m.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
  group FreeModbus/modbus/tcp
    FreeModbus/modbus/tcp/: mbtcp.c mbtcp.h
  group FreeModbus/port
    FreeModbus/port/: port.h portevent.c portevent_m.c porttcp.c
  group StartUp
    StartUp/: startup_stm32f10x_hd.s
  group Stdperiph_Driver
    StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uIP
    uIP-1.0/uip/: psock.c uip-fw.c uip-neighbor.c uip.c uip_arp.c uiplib.c
  group User
    User/: bsp_can.c bsp_can.h bsp_spi1.c bsp_spi1.h bsp_usart.c bsp_usart.h enc28j60.c enc28j60.h flash.c led.c main.c ringbuf.c rtc_time.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h tapdev.c tapdev.h timer.c timer.h uip-conf.h uip_modbus.h wdog.c
