# Keil uVision project zmms.uvprojx, settings and files
target zmms (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: zmms
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99
  c include: ..\device\include;..\frame;..\software\fatfs;..\software\uip;..\software\freemodbus\modbus\tcp;..\software\freemodbus\modbus\include;..\software\freemodbus\port;..\frame\include;..\software\ubasic;..\software\freertos\include;..\software\freertos\portable\RVDS\ARM_CM3;..\software\tcp_file;..\software\lua-5.3.4
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../user/: app.c
  group frame
    ../frame/: fsm.h modbus.c pack_list.c sha1.c list.c co_configure.c
  group device
    ../device/: w25qxx.c led.c wdog.c time.c usart.c only_id.c can.c enc28j60.c rtc.c
  group fatfs
    ../software/fatfs/: diskio.c ff.c ffsystem.c ffunicode.c
  group freertos
    ../software/freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../software/freertos/portable/RVDS/ARM_CM3/: port.c
    ../software/freertos/portable/MemMang/: heap_4.c
  group uip
    ../software/uip/: psock.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c
  group tcp_file
    ../software/tcp_file/: tcp_file.c
  group freemodbus
    ../software/freemodbus/port/: portevent.c porttcp.c
    ../software/freemodbus/modbus/: mb.c
    ../software/freemodbus/modbus/tcp/: mbtcp.c
    ../software/freemodbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group doc
    ../doc/: readme.txt
  group ubasic
    ../software/ubasic/: tokenizer.c ubasic.c write_statement.c
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:CEC 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
