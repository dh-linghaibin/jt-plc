# IAR project zmms.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\startup; ..\user; ..\lib\inc; ..\protocolstack\FreeModbus\modbus\include; ..\protocolstack\FreeModbus\modbus\tcp; ..\protocolstack\FreeModbus\port; ..\protocolstack\uIP-1.0\uip; ..\rt-thread\include; ..\rt-thread\bsp\stm32f10x; ..\rt-thread\components\drivers\include; ..\rt-thread\components\drivers\include\drivers; ..\rt-thread\bsp\stm32f10x\drivers; ..\rt-thread\components\dfs\include; ..\rt-thread\components\dfs\filesystems\elmfat; ..\rt-thread\components\net\lwip-2.0.2\src; ..\rt-thread\components\net\lwip-2.0.2\src\include; ..\rt-thread\components\net\lwip-2.0.2\src\include\ipv4; ..\rt-thread\components\net\lwip-2.0.2\src\arch\include; ..\rt-thread\components\net\lwip-2.0.2\src\include\netif
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: zmms.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\arm\config\linker\ST\stm32f103xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: REMADE.md
  group lib
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group protocolstack/freemodbus
    ../protocolstack/FreeModbus/modbus/: mb.c
  group protocolstack/freemodbus/modbus/functions
    ../protocolstack/FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group protocolstack/freemodbus/modbus/include
    ../protocolstack/FreeModbus/modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
  group protocolstack/freemodbus/modbus/tcp
    ../protocolstack/FreeModbus/modbus/tcp/: mbtcp.c mbtcp.h
  group protocolstack/freemodbus/port
    ../protocolstack/FreeModbus/port/: port.h portevent.c porttcp.c
  group protocolstack/uip
    ../protocolstack/uIP-1.0/uip/: psock.c uip-fw.c uip-neighbor.c uip-split.c uip.c uip_arp.c uiplib.c
  group rt-thread/cortex-m3
    ../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../rt-thread/libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group rt-thread/dfs
    ../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group rt-thread/dfs/elmfat
    ../rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c diskio.h ff.c ff.h ffconf.h integer.h
  group rt-thread/drivers
    ../rt-thread/bsp/stm32f10x/drivers/: board.c bxcan.c l_enc28j60.c led.c msd.c rt_stm32f10x_spi.c rtc.c usart.c
    ../rt-thread/components/drivers/spi/: spi_flash_w25qxx.c
  group rt-thread/driversframe
    ../rt-thread/components/drivers/can/: can.c
    ../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c
    ../rt-thread/components/drivers/serial/: serial.c
    ../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
  group rt-thread/kernel
    ../rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c module.h object.c scheduler.c slab.c thread.c timer.c
  group startup
    ../startup/: startup_stm32f10x_hd.s system_stm32f10x.c
  group user
    ../user/: App.c application.c canapp.c flashtask.c mbtask.c rtctask.c stm32f10x_it.c tapdev.c
    ../rt-thread/bsp/stm32f10x/: rtconfig.h
