# Keil uVision project m_uip.uvprojx, settings and files
target m_uip (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: m_uip +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\User;..\uIP-1.0\uip;..\FreeModbus\port;..\FreeModbus\modbus\functions;..\FreeModbus\modbus\include;..\FreeModbus\modbus\rtu;..\StdPeriph_Driver\inc;..\FreeModbus\modbus\tcp
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ../StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ../User/: App.c ringbuf.c rtc_time.c stm32f10x_it.c tapdev.c timer.c wdog.c bsp_can.c bsp_spi1.c bsp_usart.c enc28j60.c led.c ringbuffer.c spi_flash.c
  group uip
    ../uIP-1.0/uip/: psock.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c
  group freemodbus
    ../FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../FreeModbus/modbus/tcp/: mbtcp.c
    ../FreeModbus/port/: portevent.c porttcp.c
    ../FreeModbus/modbus/: mb.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
